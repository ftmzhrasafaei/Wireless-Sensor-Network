<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>BER</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_2</value></param>
<param><key>file</key><value>D:\DCL\finalproject\input.jpg</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_2_0</value></param>
<param><key>file</key><value>D:\DCL\finalproject\reciever2.jpg</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_2_1</value></param>
<param><key>file</key><value>D:\DCL\finalproject\reciever32.jpg</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_2_2</value></param>
<param><key>file</key><value>D:\DCL\finalproject\reciever4.jpg</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_2_3</value></param>
<param><key>file</key><value>D:\DCL\finalproject\reciever3.jpg</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_2_4</value></param>
<param><key>file</key><value>D:\DCL\finalproject\reciever43.jpg</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_2_5</value></param>
<param><key>file</key><value>D:\DCL\finalproject\reciever42.jpg</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_2_6</value></param>
<param><key>file</key><value>D:\DCL\finalproject\reciever432.jpg</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_float_to_uchar</key>
<param><key>id</key><value>blocks_float_to_uchar_0_0</value></param>
</block>
<block>
<key>blocks_float_to_uchar</key>
<param><key>id</key><value>blocks_float_to_uchar_0_1</value></param>
</block>
<block>
<key>blocks_float_to_uchar</key>
<param><key>id</key><value>blocks_float_to_uchar_0_2</value></param>
</block>
<block>
<key>blocks_float_to_uchar</key>
<param><key>id</key><value>blocks_float_to_uchar_0_3</value></param>
</block>
<block>
<key>blocks_float_to_uchar</key>
<param><key>id</key><value>blocks_float_to_uchar_0_4</value></param>
</block>
<block>
<key>blocks_float_to_uchar</key>
<param><key>id</key><value>blocks_float_to_uchar_0_5</value></param>
</block>
<block>
<key>blocks_float_to_uchar</key>
<param><key>id</key><value>blocks_float_to_uchar_0_6</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0_1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0_2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0_3</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0_4</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0_5</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0_6</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_1</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_2</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_3</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_4</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_5</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_6</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0_0</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
import cmath

class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """ Calculate BER """

    def __init__(self):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='My BER',   # will show up in GRC
            in_sig=[np.int8],
            out_sig=[np.float32]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.limit = []

    def work(self, input_items, output_items):
        """ Calculate BER"""
        in1 = input_items[0]
        out = output_items[0]
        e = 0
        for i in range(len(in1)):
            if abs(in1[i]) != 0  :
                e = 1 + e
        self.limit.append((e , len(in1)))
        l = 0
        error = 0
        for item in self.limit:
            error = item[0] + error
            l = item[1] + l
        error  = float(error) / float(l)
        for i in range(len(out)):
            out[i] = error

        #print(self.limit , error , l)
        return len(output_items[0])
</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0_1</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
import cmath

class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """ Calculate BER """

    def __init__(self):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='My BER',   # will show up in GRC
            in_sig=[np.int8],
            out_sig=[np.float32]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.limit = []

    def work(self, input_items, output_items):
        """ Calculate BER"""
        in1 = input_items[0]
        out = output_items[0]
        e = 0
        for i in range(len(in1)):
            if abs(in1[i]) != 0  :
                e = 1 + e
        self.limit.append((e , len(in1)))
        l = 0
        error = 0
        for item in self.limit:
            error = item[0] + error
            l = item[1] + l
        error  = float(error) / float(l)
        for i in range(len(out)):
            out[i] = error

        #print(self.limit , error , l)
        return len(output_items[0])
</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0_2</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
import cmath

class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """ Calculate BER """

    def __init__(self):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='My BER',   # will show up in GRC
            in_sig=[np.int8],
            out_sig=[np.float32]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.limit = []

    def work(self, input_items, output_items):
        """ Calculate BER"""
        in1 = input_items[0]
        out = output_items[0]
        e = 0
        for i in range(len(in1)):
            if abs(in1[i]) != 0  :
                e = 1 + e
        self.limit.append((e , len(in1)))
        l = 0
        error = 0
        for item in self.limit:
            error = item[0] + error
            l = item[1] + l
        error  = float(error) / float(l)
        for i in range(len(out)):
            out[i] = error

        #print(self.limit , error , l)
        return len(output_items[0])
</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0_3</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
import cmath

class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """ Calculate BER """

    def __init__(self):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='My BER',   # will show up in GRC
            in_sig=[np.int8],
            out_sig=[np.float32]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.limit = []

    def work(self, input_items, output_items):
        """ Calculate BER"""
        in1 = input_items[0]
        out = output_items[0]
        e = 0
        for i in range(len(in1)):
            if abs(in1[i]) != 0  :
                e = 1 + e
        self.limit.append((e , len(in1)))
        l = 0
        error = 0
        for item in self.limit:
            error = item[0] + error
            l = item[1] + l
        error  = float(error) / float(l)
        for i in range(len(out)):
            out[i] = error

        #print(self.limit , error , l)
        return len(output_items[0])
</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0_4</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
import cmath

class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """ Calculate BER """

    def __init__(self):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='My BER',   # will show up in GRC
            in_sig=[np.int8],
            out_sig=[np.float32]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.limit = []

    def work(self, input_items, output_items):
        """ Calculate BER"""
        in1 = input_items[0]
        out = output_items[0]
        e = 0
        for i in range(len(in1)):
            if abs(in1[i]) != 0  :
                e = 1 + e
        self.limit.append((e , len(in1)))
        l = 0
        error = 0
        for item in self.limit:
            error = item[0] + error
            l = item[1] + l
        error  = float(error) / float(l)
        for i in range(len(out)):
            out[i] = error

        #print(self.limit , error , l)
        return len(output_items[0])
</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0_5</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
import cmath

class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """ Calculate BER """

    def __init__(self):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='My BER',   # will show up in GRC
            in_sig=[np.int8],
            out_sig=[np.float32]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.limit = []

    def work(self, input_items, output_items):
        """ Calculate BER"""
        in1 = input_items[0]
        out = output_items[0]
        e = 0
        for i in range(len(in1)):
            if abs(in1[i]) != 0  :
                e = 1 + e
        self.limit.append((e , len(in1)))
        l = 0
        error = 0
        for item in self.limit:
            error = item[0] + error
            l = item[1] + l
        error  = float(error) / float(l)
        for i in range(len(out)):
            out[i] = error

        #print(self.limit , error , l)
        return len(output_items[0])
</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0_6</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
import cmath

class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """ Calculate BER """

    def __init__(self):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='My BER',   # will show up in GRC
            in_sig=[np.int8],
            out_sig=[np.float32]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.limit = []

    def work(self, input_items, output_items):
        """ Calculate BER"""
        in1 = input_items[0]
        out = output_items[0]
        e = 0
        for i in range(len(in1)):
            if abs(in1[i]) != 0  :
                e = 1 + e
        self.limit.append((e , len(in1)))
        l = 0
        error = 0
        for item in self.limit:
            error = item[0] + error
            l = item[1] + l
        error  = float(error) / float(l)
        for i in range(len(out)):
            out[i] = error

        #print(self.limit , error , l)
        return len(output_items[0])
</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Node 1 to Node 2</value></param>
<param><key>marker1</key><value>2</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Node 1 to Node 3</value></param>
<param><key>marker2</key><value>7</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value>Node 1 to Node 4</value></param>
<param><key>marker3</key><value>4</value></param>
<param><key>color4</key><value>"yellow"</value></param>
<param><key>label4</key><value>Node 2 to Node 3</value></param>
<param><key>marker4</key><value>1</value></param>
<param><key>color5</key><value>"Dark Blue"</value></param>
<param><key>label5</key><value>Node 2 to Node 4</value></param>
<param><key>marker5</key><value>9</value></param>
<param><key>color6</key><value>"cyan"</value></param>
<param><key>label6</key><value>Node 3 to Node 4</value></param>
<param><key>marker6</key><value>2</value></param>
<param><key>color7</key><value>"magenta"</value></param>
<param><key>label7</key><value>Node 2 to Node 3 to Node 4</value></param>
<param><key>marker7</key><value>0</value></param>
<param><key>name</key><value>"BER"</value></param>
<param><key>nconnections</key><value>7</value></param>
<param><key>size</key><value>10</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>0.1</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<connection><source_block_id>blocks_file_source_2</source_block_id><sink_block_id>blocks_sub_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_2</source_block_id><sink_block_id>blocks_sub_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_2</source_block_id><sink_block_id>blocks_sub_xx_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_2</source_block_id><sink_block_id>blocks_sub_xx_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_2</source_block_id><sink_block_id>blocks_sub_xx_0_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_2</source_block_id><sink_block_id>blocks_sub_xx_0_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_2</source_block_id><sink_block_id>blocks_sub_xx_0_6</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_2_0</source_block_id><sink_block_id>blocks_sub_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_file_source_2_1</source_block_id><sink_block_id>blocks_sub_xx_0_3</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_file_source_2_2</source_block_id><sink_block_id>blocks_sub_xx_0_2</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_file_source_2_3</source_block_id><sink_block_id>blocks_sub_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_file_source_2_4</source_block_id><sink_block_id>blocks_sub_xx_0_5</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_file_source_2_5</source_block_id><sink_block_id>blocks_sub_xx_0_4</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_file_source_2_6</source_block_id><sink_block_id>blocks_sub_xx_0_6</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_uchar_0_0</source_block_id><sink_block_id>epy_block_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_uchar_0_1</source_block_id><sink_block_id>epy_block_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_uchar_0_2</source_block_id><sink_block_id>epy_block_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_uchar_0_3</source_block_id><sink_block_id>epy_block_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_uchar_0_4</source_block_id><sink_block_id>epy_block_0_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_uchar_0_5</source_block_id><sink_block_id>epy_block_0_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_uchar_0_6</source_block_id><sink_block_id>epy_block_0_6</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0_0</source_block_id><sink_block_id>blocks_float_to_uchar_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0_1</source_block_id><sink_block_id>blocks_float_to_uchar_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0_2</source_block_id><sink_block_id>blocks_float_to_uchar_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0_3</source_block_id><sink_block_id>blocks_float_to_uchar_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0_4</source_block_id><sink_block_id>blocks_float_to_uchar_0_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0_5</source_block_id><sink_block_id>blocks_float_to_uchar_0_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0_6</source_block_id><sink_block_id>blocks_float_to_uchar_0_6</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_1</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_2</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_3</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_4</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_5</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_6</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>epy_block_0_0</source_block_id><sink_block_id>blocks_throttle_0_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0_1</source_block_id><sink_block_id>blocks_throttle_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0_2</source_block_id><sink_block_id>blocks_throttle_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0_3</source_block_id><sink_block_id>blocks_throttle_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0_4</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0_5</source_block_id><sink_block_id>blocks_throttle_0_6</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0_6</source_block_id><sink_block_id>blocks_throttle_0_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
